# Keil uVision project Multi_Timer_Blinky.uvprojx, settings and files
target flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: Keil.LPC800_DFP.1.5.0-dev1
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Multi_Timer_Blinky
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Source_Code\peripherals_lib\inc; ..\..\Source_Code\utilities_lib\inc; ..\..\Source_Code\common\inc; ..\..\Source_Code\Multi_Timer_Blinky\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group src
    ../../Source_Code/Multi_Timer_Blinky/src/: Multi_Timer_Blinky.c Multi_Timer_Blinky_ISR.c
    ../../Source_Code/common/src/: Keil_startup.s system.c
  group inc
    ../../Source_Code/Multi_Timer_Blinky/inc/: Multi_Timer_Blinky.h chip_setup.h
  group docs
    ../../Source_Code/Multi_Timer_Blinky/docs/: README.txt
  group libs
    ../peripherals_lib/Objects/: peripherals_lib.lib
    ../utilities_lib/Objects/: utilities_lib.lib
