# Keil uVision project CapTouch_3Sensor_Slider.uvprojx, settings and files
target flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC845M301JHI48 NXP
  pack: Keil.LPC800_DFP.1.5.0-dev1
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: CapTouch_3Sensor_Slider
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../Source_Code/peripherals_lib/inc; ../../Source_Code/utilities_lib/inc; ../../Source_Code/common/inc; ../../Source_Code/CapTouch_3Sensor_Slider/inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group src
    ../../Source_Code/CapTouch_3Sensor_Slider/src/: CapTouch_3Sensor_Slider_main.c CapTouch_3Sensor_Slider_ISRs.c
    ../../Source_Code/common/src/: Filters.c Functions.c Keil_Retarget.c Keil_startup.s Serial.c system.c
  group inc
    ../../Source_Code/CapTouch_3Sensor_Slider/inc/: chip_setup.h
  group libs
    ../peripherals_lib/Objects/: peripherals_lib.lib
    ../utilities_lib/Objects/: utilities_lib.lib
  group docs
    ../../Source_Code/CapTouch_3Sensor_Slider/docs/: README.txt
