# Keil uVision project Ctimer_PWM.uvprojx, settings and files
target flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC845M301JBD64 NXP
  pack: Keil.LPC800_DFP.1.5.0-dev1
  cpu: IRAM(0x10000000,0x00004000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ctimer_PWM
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../Source_Code/peripherals_lib/inc; ../../Source_Code/utilities_lib/inc; ../../Source_Code/common/inc; ../../Source_Code/Ctimer_PWM/inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x4000
  group src
    ../../Source_Code/Ctimer_PWM/src/: Ctimer_PWM_main.c Ctimer_PWM_funcs.c
    ../../Source_Code/common/src/: Keil_Retarget.c Keil_startup.s Serial.c system.c
  group inc
    ../../Source_Code/Ctimer_PWM/inc/: chip_setup.h Ctimer_pwm.h
  group libs
    ../peripherals_lib/Objects/: peripherals_lib.lib
    ../utilities_lib/Objects/: utilities_lib.lib
  group docs
    ../../Source_Code/Ctimer_PWM/docs/: README.txt
