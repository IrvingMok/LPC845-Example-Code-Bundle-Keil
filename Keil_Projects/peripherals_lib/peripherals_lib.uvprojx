# Keil uVision project peripherals_lib.uvprojx, settings and files
target flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.5.0-dev1
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: peripherals_lib (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Source_Code\peripherals_lib\inc; ..\..\Source_Code\utilities_lib\inc; ..\..\Source_Code\common\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../../Source_Code/peripherals_lib/src/: syscon.c swm.c gpio.c i2c.c
  group inc
    ../../Source_Code/peripherals_lib/inc/: acomp.h adc.h dma.h fro.h gpio.h i2c.h iocon.h mrt.h pmu.h sct.h spi.h swm.h syscon.h uart.h wkt.h wwdt.h
